# Keil uVision project STM32F051R8_Demo.uvproj, settings and files
target tag_IAP (ARM-ADS)
  device: STM32F051C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: bootloadr_smart_tag +hex
  AfterMake: D:\Keil\ARM\ARMCC\bin\fromelf.exe --bin --output ../bootloadr_smart_tag.bin ./out/bootloadr_smart_tag.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\inc;..\STM32F0xx_StdPeriph_Driver\inc;..\a7139;..\..\a7139_IAP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1400
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../: stm32f0xx_it.c system_stm32f0xx.c
    ../src/: main.c flash_if.c crc16.c
  group MDK-ARM
    ../: startup_stm32f0xx.s
  group STM32F2XX_LIB
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_flash.c
