# Keil uVision project STM32F051R8_Demo.uvproj, settings and files
target tag_wakeup_model (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: a7139_bugle +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\inc;..\STM32F0xx_StdPeriph_Driver\inc;..\..\a7139_touchuan;..\a7139;..\..\a7139_huanxing;..\sleep_wake;..\..\a7139_huanxing_new
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../: stm32f0xx_it.c system_stm32f0xx.c
    ../src/: main.c app_msg.c crc16.c
    ../sleep_wake/: sleep_wake.c
  group BSP
    ../src/: BSP_USART2.c
  group MDK-ARM
    ../: startup_stm32f0xx.s
  group STM32F2XX_LIB
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group a7139
    ../a7139/: a7139.c a7139_api.c
