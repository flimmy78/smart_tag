# Keil uVision project smart_tags_m0.uvproj, settings and files
target smart_tags_m0 (ARM-ADS)
  device: STM32F051C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: smart_tags_m0
  AfterMake: D:\Keil\ARM\ARMCC\bin\fromelf.exe --bin --output ../app_smart_tags.bin ../obj/smart_tags_m0.axf
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER STM32F0XX PRINT_DEBUG
  c include: ..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\Inc;..\..\Libraries\a7139;..\..\..\
  library: MicroLIB
  memory RVCT4: ROM 0x8001400 size 0x7400
  memory RVCT9: RAM 0x200000c0 size 0x2000
  group Starup
    ./: startup_stm32f0xx.s
  group Usr
    ../../Src/: main.c system_stm32f0xx.c stm32f0xx_it.c bsp.c BSP_USART2.c usr_rtc.c usr_lowpower.c crc16.c menu.c engineer_mode.c pmw_led.c
  group App
    ../../Src/: app_msg.c pkt_build.c app_algo.c app_gui.c app_state.c app_wrscreen.c app_flash.c app_key.c app_usr_function.c
  group lcd_driver
    ../../Src/: ep12864.c
  group STM32F0xx_StdPeriph_Driver
    ../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_iwdg.c stm32f0xx_rcc.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_pwr.c stm32f0xx_exti.c stm32f0xx_syscfg.c stm32f0xx_misc.c stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_usart.c
  group A7139
    ../../Libraries/a7139/: a7139.c a7139_api.c
